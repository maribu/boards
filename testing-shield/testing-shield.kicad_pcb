# Repository maribu/boards

## KiCad design testing-shield/testing-shield.kicad_pcb

Parts:
C1, C2: 0.1 uF; C_Disc_D7.5mm_W4.4mm_P5.00mm
J1: I2C Grove; grove_i2c
J2: I2C Socket; PinSocket_1x04_P2.54mm_Vertical
J3: I2C Header; PinHeader_1x04_P2.54mm_Vertical
J4: Side SPI; PinHeader_2x03_P2.54mm_Vertical
J5: ISP SPI; PinHeader_2x03_P2.54mm_Vertical
J6: UART Header; PinHeader_1x04_P2.54mm_Vertical
J7: UART Grove; grove_uart
JP1: ADDR0; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
JP2: ADDR1; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
JP3: ADDR2; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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
R1, R2, R4, R6, R8: 20K; R_0805_2012Metric
R3, R5, R7: 10K; R_0805_2012Metric
R9, R10: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
SW1: UART; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
SW2: Side SPI; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
SW3: ISP SPI; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm
SW4: GPIO; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
SW5: Select VCC; PinHeader_1x03_P2.54mm_Vertical
SW6: Reset; SW_PUSH_6mm_H4.3mm
U1: PCF8574; DIP-16_W7.62mm
XA1: Arduino_Uno_R3_Shield

Connections:
+3.3V: SW5.1 (A), XA1.3V3 (3.3V)
+5V: SW5.3 (C), XA1.5V1 (5V)
/A0: R7.2, R8.1, XA1.A0
/A1: C1.1, R9.2, XA1.A1
/A2: C2.1, R10.2, XA1.A2
/A3: XA1.A3
/A4: XA1.A4
/A5: XA1.A5
/CIPO_0: J4.5, SW2.2, XA1.D12
/CIPO_1: J5.5, SW3.2, XA1.MISO (SPI_MISO)
/COPI_0: J4.4, SW2.1, XA1.D11
/COPI_1: J5.4, SW3.1, XA1.MOSI (SPI_MOSI)
/CS: J4.6, J5.6, SW4.3, XA1.D10 (D10_CS)
/D3: SW4.1, XA1.D3 (D3_INT1)
/D4: SW4.4, XA1.D4
/D7: SW4.2, XA1.D7
/D8: U1.4 (P0), XA1.D8
/D9: U1.5 (P1), XA1.D9
/IOEXT_ADDR0: JP1.2 (C), U1.1 (A0)
/IOEXT_ADDR1: JP2.2 (C), U1.2 (A1)
/IOEXT_ADDR2: JP3.2 (C), U1.3 (A2)
/IOEXT_INT: U1.13 (~INT), XA1.D2 (D2_INT0)
/PWM0: R10.1, XA1.D5
/PWM1: R9.1, XA1.D6
/R-2R_0: R8.2, U1.9 (P4)
/R-2R_1: R6.2, U1.10 (P5)
/R-2R_2: R4.2, U1.11 (P6)
/R-2R_3: R2.2, U1.12 (P7)
/RST: SW6.1, XA1.RST1 (RESET), XA1.RST2 (SPI_RESET)
/RXD: J6.4, J7.1, SW1.2, XA1.D0 (D0/RX)
/SCK_0: J4.3, U1.6 (P2), XA1.D13
/SCK_1: J5.3, U1.7 (P3), XA1.SCK (SPI_SCK)
/SCL: J1.1, J2.3, J3.3, U1.14 (SCL), XA1.SCL
/SDA: J1.2, J2.4, J3.4, U1.15 (SDA), XA1.SDA
/TXD: J6.3, J7.2, SW1.1, XA1.D1 (D1/TX)
GND: C1.2, C2.2, J1.4, J2.2, J3.2, J4.2, J5.2, J6.2, J7.4, JP1.1 (A), JP2.1 (A), JP3.1 (A), R1.1, SW6.2, U1.8 (VSS), XA1.GND1 (GND), XA1.GND2 (GND), XA1.GND3 (GND), XA1.GND4 (SPI_GND)
unnamed: R1.2, R2.1, R3.1
unnamed: R3.2, R4.1, R5.1
unnamed: R5.2, R6.1, R7.1
VCC: J1.3, J2.1, J3.1, J4.1, J5.1, J6.1, J7.3, JP1.3 (B), JP2.3 (B), JP3.3 (B), SW5.2 (B), U1.16 (VDD)

Notes on the sheet:
Loopback Enable/Disable Switches
Shield Headers
SPI Connectors
I2C GPIO Extender
I2C Connectors
PWM + Low Pass Filter DAC
"DAC"s
4 Bit R-2R Resistor Ladder DAC
UART Connectors
I2C Address Selection
Utility Switches / Buttons

Board: 2 copper layers, 79.5 x 58.4 mm, 30 parts (11 on the bottom side), 37 nets.

## KiCad design mspduino/mspduino.kicad_pcb

Parts:
C1, C2: 100nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: USB_B_Mini; USB_Mini-B-Through-Hole
J2: Clock Debug; PinHeader_1x04_P2.54mm_Vertical
NT1, NT2: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: Reset; SW_PUSH_6mm_H5mm
U1: MSP430-F1611; Olimex MSP430-H1611
U2: CH340N; SOP-8_3.9x4.9mm_P1.27mm
U3: LDO-3V3
XA1: Arduino UNO Headers; Arduino_Uno_R3_BOARD

Connections:
+5V: J1.1 (VBUS), U3.3 (VIN), XA1.5V1 (5V), XA1.5V2 (SPI_5V)
/A0: U1.59 (P6.0/A0), XA1.A0
/A1: U1.60 (P6.1/A1), XA1.A1
/A2: U1.61 (P6.2/A2), XA1.A2
/A3: U1.2 (P6.3/A3), XA1.A3
/A4: U1.3 (P6.4/A4), XA1.A4
/A5: U1.4 (P6.5/A5), XA1.A5
/ACLK: J2.3, U1.50 (P5.6/ACLK)
/CIPO0: U1.30 (P3.2/SOMI0), XA1.D12
/CIPO1: U1.46 (P5.2/SOMI1), XA1.MISO (SPI_MISO)
/COPI0/SDA: U1.29 (P3.1/SIMO0/SDA), XA1.D11, XA1.SDA
/COPI1: U1.45 (P5.1/SIMO1), XA1.MOSI (SPI_MOSI)
/CS: U1.16 (P1.4/SMCLK), XA1.D10 (D10_CS)
/D2: U1.12 (P1.0/TACLK), XA1.D2 (D2_INT0)
/D3: U1.13 (P1.1/TA0), XA1.D3 (D3_INT1)
/D4: U1.17 (P1.5/TA0), XA1.D4
/D5: U1.14 (P1.2/TA1), XA1.D5
/D6: U1.15 (P1.3/TA2), XA1.D6
/D7: U1.18 (P1.6/TA1), XA1.D7
/D8: U1.19 (P1.7/TA2), XA1.D8
/D9: U1.36 (P4.0/TB0), XA1.D9
/MCLK: J2.1, U1.48 (P5.4/MCLK)
/RXD0: U1.33 (P3.5/URXD0), XA1.D0 (D0/RX)
/RXD1: U1.35 (P3.7/URXD1), U2.6 (TXD)
/R_{OSC}: R1.1, U1.25 (P2.5/R_{OSC})
/SCK0/SCL: U1.31 (P3.3/UCLK0/SCL), XA1.D13, XA1.SCL
/SCK1: U1.47 (P5.3/UCLK1), XA1.SCK (SPI_SCK)
/SMCLK: J2.2, U1.49 (P5.5/SMCLK)
/TXD0: U1.32 (P3.4/UTXD0), XA1.D1 (D1/TX)
/TXD1: U1.34 (P3.6/UTXD1), U2.7 (RXD)
/USB_D+: J1.3 (D+), U2.1 (UD+)
/USB_D-: J1.2 (D-), U2.2 (UD-)
/~RST: SW1.2, U1.58 (~RST/NMI), XA1.RST1 (RESET), XA1.RST2 (SPI_RESET)
GND: C1.1, C2.2, J1.5 (GND), J1.6 (Shield), J2.4, NT2.1, SW1.1, U1.63 (DV_{SS}), U2.3 (GND), U3.1 (GND), XA1.GND1 (GND), XA1.GND2 (GND), XA1.GND3 (GND), XA1.GND4 (SPI_GND)
GNDA: NT2.2, U1.62 (AV_{SS})
VCC: C1.2, C2.1, NT1.1, R1.2, U1.1 (DV_{CC}), U2.5 (VCC), U2.8 (V3), U3.2 (VOUT), XA1.3V3 (3.3V)
VDDA: NT1.2, U1.64 (AV_{CC})

Board: 2 copper layers, 68.6 x 53.3 mm, 12 parts (1 on the bottom side), 37 nets.

## KiCad design atmega1284p/atmega1284p.kicad_pcb

Parts:
C1: 10nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2, C3: 10µF; electrolytic_capacitor_10uf
C4, C7: 10pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C5, C6: 20pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C8, C9: 100nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_DIN965
J1: PA; PinHeader_1x08_P2.54mm_Vertical
J2: PB; PinHeader_1x08_P2.54mm_Vertical
J3: PC; PinHeader_1x08_P2.54mm_Vertical
J4: PD; PinHeader_1x08_P2.54mm_Vertical
J5: I2C1; PinHeader_1x04_P2.54mm_Vertical
J6: I2C2; PinHeader_1x04_P2.54mm_Vertical
J7: Power; PinHeader_1x04_P2.54mm_Vertical
J8: GND; PinHeader_1x04_P2.54mm_Vertical
J9: AVR-JTAG-10; PinHeader_2x05_P2.54mm_Vertical
J10: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J11: USB_B_Mini; USB_Mini-B-Through-Hole
J12: CC1101_Breakout
SW1: SW_RST; SW_PUSH_6mm
SW2: TOSC; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1: ATmega1284P-PU; DIP-40_W15.24mm
U2: LDO-3V3
U3: CH340N; SOP-8_3.9x4.9mm_P1.27mm
Y1: 12MHz; Crystal_HC49-4H_Vertical
Y2: 32.768kHz; Crystal_DS10_D1.0mm_L4.3mm_Horizontal

Connections:
+5V: J7.1, J7.2, J11.1 (VBUS), U2.3 (VIN)
/PA0: J1.1, U1.40 (PA0)
/PA1: J1.2, U1.39 (PA1)
/PA2: J1.3, U1.38 (PA2)
/PA3: J1.4, U1.37 (PA3)
/PA4: J1.5, U1.36 (PA4)
/PA5: J1.6, U1.35 (PA5)
/PA6: J1.7, U1.34 (PA6)
/PA7: J1.8, U1.33 (PA7)
/PB0: J2.1, J12.8 (CSN), U1.1 (PB0)
/PB1: J2.2, U1.2 (PB1)
/PB2_INT2: J2.3, J12.7 (GDO0), U1.3 (PB2)
/PB3_OC0A: J2.4, U1.4 (PB3)
/PB4_OC0B: J2.5, U1.5 (PB4)
/PB5_MOSI: J2.6, J10.1 (MISO), J12.3 (MOSI), U1.6 (PB5)
/PB6_MISO: J2.7, J10.4 (MOSI), J12.5 (MISO), U1.7 (PB6)
/PB7_SCK: J2.8, J10.3 (SCK), J12.4 (SCK), U1.8 (PB7)
/PC0_SCL: J3.1, J5.3, J6.3, U1.22 (PC0)
/PC1_SDA: J3.2, J5.4, J6.4, U1.23 (PC1)
/PC2_TCK: J3.3, J9.1 (TCK), U1.24 (PC2)
/PC3_TMS: J3.4, J9.5 (TMS), U1.25 (PC3)
/PC4_TDO: J3.5, J9.3 (TDO), U1.26 (PC4)
/PC5_TDI: J3.6, J9.9 (TDI), U1.27 (PC5)
/PC6_TOSC1: J3.7, SW2.2, U1.28 (PC6)
/PC7_TOSC2: J3.8, SW2.1, U1.29 (PC7)
/PD0_RXD0: J4.1, U1.14 (PD0), U3.6 (TXD)
/PD1_TXD0: J4.2, U1.15 (PD1), U3.7 (RXD)
/PD2_INT0: J4.3, U1.16 (PD2)
/PD3_INT1: J4.4, J12.6 (GDO2), U1.17 (PD3)
/PD4_OC1B: J4.5, U1.18 (PD4)
/PD5_OC1A: J4.6, U1.19 (PD5)
/PD6_OC2B: J4.7, U1.20 (PD6)
/PD7_OC2A: J4.8, U1.21 (PD7)
/RESET: J9.6 (~SRST), J10.5 (~RST), SW1.2, U1.9 (~RESET)
/XTAL1: C5.2, U1.13 (XTAL1), Y1.1
/XTAL2: C6.1, U1.12 (XTAL2), Y1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.1, C9.2, J5.2, J6.2, J8.1, J8.2, J8.3, J8.4, J9.2 (GND), J9.10 (GND), J10.6 (GND), J11.5 (GND), J11.6 (Shield), J12.1 (GND), SW1.1, U1.11 (GND), U1.31 (GND), U2.1 (GND), U3.3 (GND)
unnamed: C4.1, SW2.3, Y2.1
unnamed: C7.1, SW2.4, Y2.2
unnamed: J11.3 (D+), U3.1 (UD+)
unnamed: J11.2 (D-), U3.2 (UD-)

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
Board: 2 copper layers, 48.3 x 99.1 mm, 32 parts (0 on the bottom side), 42 nets.

## KiCad design 4dof-arm/4dof-arm.kicad_pcb

Board: 2 copper layers, 73.0 x 61.7 mm, 20 parts (0 on the bottom side), 22 nets.

Parts:
C1, C2: 10 uF; electrolytic_capacitor_10uf
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Servo-0; Servo
J2: Servo-1; Servo
J3: Servo-2; Servo
J4: Servo-3; Servo
J5: I2C; I2C-Socket-2.54mm
J6: I2C; grove_i2c
J7: UART; grove_uart
J8: Reset; PinHeader_1x01_P2.54mm_Vertical
U1: bluepill-stm32f103c8
U2: NRF24L01_Breakout; nRF24L01_Breakout
U3, U4, U5, U6: WS2811B; WS2812B

Connections:
+5V: C1.1, C2.1, J1.2, J2.2, J3.2, J4.2, U1.18 (5V), U3.1 (VDD), U4.1 (VDD), U5.1 (VDD), U6.1 (VDD)
/RST: J8.1, U1.37 (RST)
/RXD: J7.1, U1.7 (PA10_RXD0)
/SCL: J5.3, J6.1, U1.16 (PB8_SCL0)
/SDA: J5.4, J6.2, U1.17 (PB9_SDA0)
/SRV0_CTRL: J1.3, U1.12 (PB4_PWM0)
/SRV1_CTRL: J2.3, U1.13 (PB5_PWM1)
/SRV2_CTRL: J3.3, U1.33 (PB0_PWM2)
/SRV3_CTRL: J4.3, U1.34 (PB1_PWM3)
/TXD: J7.2, U1.6 (PA9_TXD0)
/WS281X: U1.10 (PA15), U3.4 (DIN)
/nRF_CE: U1.27 (PA2_TXD1), U2.3 (CE)
/nRF_IRQ: U1.28 (PA3_RXD1), U2.8 (IRQ)
/nRF_MISO: U1.3 (PB14_MISO0), U2.7 (MISO)
/nRF_MOSI: U1.4 (PB15_MOSI0), U2.6 (MOSI)
/nRF_SCK: U1.2 (PB13_SCLK0), U2.5 (SCK)
/nRF_~CSN: U1.1 (PB12_CS0), U2.4 (~CSN)
GND: C1.2, C2.2, J1.1, J2.1, J3.1, J4.1, J5.2, J6.4, J7.4, U1.19 (GND), U1.39 (GND), U1.40 (GND), U2.1 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND)
unnamed: U3.2 (DOUT), U4.4 (DIN)
unnamed: U4.2 (DOUT), U5.4 (DIN)
unnamed: U5.2 (DOUT), U6.4 (DIN)
VCC: J5.1, J6.3, J7.3, U1.20 (3V3), U1.38 (3V3), U2.2 (VCC)

## KiCad design xmas/xmas-pcb.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_15x7.5RM7.6
C1, C2, C3: 10µF; electrolytic_capacitor_10uf
C4: 0.1µF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: ICSP; PinHeader_2x03_P2.54mm_Vertical
J2: UART; PinHeader_1x04_P2.54mm_Vertical
J3: GPIOs; PinHeader_1x08_P2.54mm_Vertical
J4: I2C; PinHeader_1x04_P2.54mm_Vertical
J5: USB_A; USB_A_Male-Through-Hole
R1: 1kΩ; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U2, U3, U4, U5, U6, U7, U8, U9, U10, U11: WS2811B; WS2812B

Connections:
+5V: C1.1, C2.1, C3.1, J1.2, J2.1, J3.1, J4.1, J5.1 (VBUS), U1.4 (VCC), U1.6 (VCC), U2.1 (VDD), U3.1 (VDD), U4.1 (VDD), U5.1 (VDD), U6.1 (VDD), U7.1 (VDD), U8.1 (VDD), U9.1 (VDD), U10.1 (VDD), U11.1 (VDD)
/ADC6: U1.19 (ADC6)
/ADC7: U1.22 (ADC7)
/AREF: U1.20 (AREF)
/AVCC: U1.18 (AVCC)
/PB0: U1.12 (PB0), U2.4 (DIN)
/PB1: U1.13 (PB1)
/PB2: U1.14 (PB2)
/PB3-MOSI: J1.4, U1.15 (PB3)
/PB4-MISO: J1.1, U1.16 (PB4)
/PB5-SCK: J1.3, U1.17 (PB5)
/PB6: U1.7 (XTAL1/PB6)
/PB7: U1.8 (XTAL2/PB7)
/PC0-ADC0: J3.6, U1.23 (PC0)
/PC1-ADC1: J3.7, U1.24 (PC1)
/PC2: U1.25 (PC2)
/PC3: U1.26 (PC3)
/PC4-SDA: J4.4, U1.27 (PC4)
/PC5-SCL: J4.3, U1.28 (PC5)
/PD0-RXD: J2.3, U1.30 (PD0)
/PD1-TXD: J2.2, U1.31 (PD1)
/PD2-INT0: J3.2, U1.32 (PD2)
/PD3-INT1: J3.3, U1.1 (PD3)
/PD4: J3.4, U1.2 (PD4)
/PD5-PWM: J3.5, U1.9 (PD5)
/PD6-PWM: R1.2, U1.10 (PD6)
/PD7: U1.11 (PD7)
/RST: J1.5, U1.29 (~RESET/PC6)
GND: BZ1.2 (+), C1.2, C2.2, C3.2, C4.2, J1.6, J2.4, J3.8, J4.2, J5.4 (GND), J5.5 (Shield), U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND), U8.3 (GND), U9.3 (GND), U10.3 (GND), U11.3 (GND)
unnamed: BZ1.1 (-), C4.1, R1.1
unnamed: U2.2 (DOUT), U3.4 (DIN)
unnamed: U3.2 (DOUT), U4.4 (DIN)
unnamed: U4.2 (DOUT), U5.4 (DIN)
unnamed: U5.2 (DOUT), U6.4 (DIN)
unnamed: U6.2 (DOUT), U7.4 (DIN)
unnamed: U7.2 (DOUT), U8.4 (DIN)
unnamed: U8.2 (DOUT), U9.4 (DIN)
unnamed: U10.2 (DOUT), U11.4 (DIN)
unnamed: U9.2 (DOUT), U10.4 (DIN)
