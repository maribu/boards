# Repository maribu/boards (continued)

## KiCad design xmas/xmas-pcb.kicad_pcb (continued)

Board: 2 copper layers, 45.7 x 88.3 mm, 22 parts (10 on the bottom side), 28 nets.

## KiCad design atmega328p/atmega328p.kicad_pcb

Parts:
C1: 10µF; electrolytic_capacitor_10uf
C2: 1µF; electrolytic_capacitor_10uf
C3, C4: 10pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C5, C6: 20pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C7, C8: 47pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1: LED; LED_D3.0mm
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J2: PB; PinHeader_1x08_P2.54mm_Vertical
J3: PC; PinHeader_1x07_P2.54mm_Vertical
J4, J6: I2C; PinHeader_1x04_P2.54mm_Vertical
J5: PD; PinHeader_1x08_P2.54mm_Vertical
J7: USB_B_Mini; USB_Mini-B-Through-Hole
JP1: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 33Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 330Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SW1: SW_Clock; SW_DIP_SPSTx04_Slide_9.78x12.34mm_W7.62mm_P2.54mm
SW2: SW_Push; SW_PUSH_6mm
U1: ATmega328P-PU; DIP-28_W7.62mm
U2: LDO-3V3
U3: HT42B534-1SOP10
Y1: 32.678kHz; Crystal_DS10_D1.0mm_L4.3mm_Horizontal
Y2: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: JP1.1 (A), R3.1, U2.2 (VOUT), U3.7 (VDDIO)
+5V: J7.1 (VBUS), JP1.3 (B), U2.3 (VIN), U3.2 (VDD)
/PB0: J2.1, U1.14 (PB0)
/PB1_OC1A: J2.2, U1.15 (PB1)
/PB2_SS: J2.3, U1.16 (PB2)
/PB3_MOSI: J1.4 (MOSI), J2.4, U1.17 (PB3)
/PB4_MISO: J1.1 (MISO), J2.5, U1.18 (PB4)
/PB5_SCK: J1.3 (SCK), J2.6, U1.19 (PB5)
/PB6_XTAL1: J2.7, SW1.1, SW1.3, U1.9 (XTAL1/PB6)
/PB7_XTAL2: J2.8, SW1.2, SW1.4, U1.10 (XTAL2/PB7)
/PC0_ADC0: J3.1, U1.23 (PC0)
/PC1_ADC1: J3.2, U1.24 (PC1)
/PC2_ADC2: J3.3, U1.25 (PC2)
/PC3_ADC3: J3.4, U1.26 (PC3)
/PC4_SDA: J3.5, J4.4, J6.4, U1.27 (PC4)
/PC5_SCL: J3.6, J4.3, J6.3, U1.28 (PC5)
/PC6_RESET: J3.7
/PD0_RXD: J5.1, U1.2 (PD0), U3.4 (TX)
/PD1_TXD: J5.2, U1.3 (PD1), U3.8 (RX)
/PD2_INT0: J5.3, U1.4 (PD2)
/PD3_INT1: J5.4, U1.5 (PD3)
/PD4: J5.5, U1.6 (PD4)
/PD5_OC0B: J5.6, U1.11 (PD5)
/PD6_OC0A: J5.7, U1.12 (PD6)
/PD7: J5.8, U1.13 (PD7)
/RESET: J1.5 (~RST), SW2.2, U1.1 (~RESET/PC6)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, J1.6 (GND), J4.2, J6.2, J7.5 (GND), J7.6 (Shield), SW2.1, U1.8 (GND), U1.22 (GND), U2.1 (GND), U3.9 (GND)
unnamed: C2.1, U3.3 (V33O)
unnamed: C3.2, SW1.5, Y1.1
unnamed: C4.2, SW1.6, Y1.2
unnamed: C5.2, SW1.7, Y2.2
unnamed: C6.2, SW1.8, Y2.1
unnamed: C7.1, R2.2, U3.6 (UDET), U3.10 (D-)
unnamed: C8.1, R1.2, U3.1 (D+)
unnamed: D1.1 (K), U3.5 (LED)
unnamed: D1.2 (A), R3.2
unnamed: J7.2 (D-), R2.1
unnamed: J7.3 (D+), R1.1
VCC: C1.1, J1.2 (VCC), J4.1, J6.1, JP1.2 (C), U1.7 (VCC), U1.20 (AVCC)

Board: 2 copper layers, 48.3 x 48.3 mm, 27 parts (0 on the bottom side), 38 nets.

## KiCad design corerf/corerf.kicad_pcb

Parts:
C1, C2: 47pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3: 100nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C4: 1µF; electrolytic_capacitor_10uf
D1: LED; LED_D3.0mm
J1: I2C_1; PinSocket_1x04_P2.54mm_Vertical
J2: I2C_2; PinSocket_1x04_P2.54mm_Vertical
J3: CoreRF-Header
J4: ISP; PinHeader_2x03_P2.54mm_Vertical
J5: JTAG; PinHeader_2x05_P2.54mm_Vertical
J6: USB_B_Mini; USB_Mini-B-Through-Hole
R1, R2: 33Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R3: 330Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1: LDO-3V3
U2: HT42B534-1SOP10

Connections:
+3V3: C3.1, J1.1, J2.1, J3.2, J4.2 (VCC), J5.4 (VREF), R3.1, U1.2 (VOUT), U2.7 (VDDIO)
+5V: J3.1, J6.1 (VBUS), U1.3 (VIN), U2.2 (VDD)
/AREF: J3.10
/PB1_SCK: J3.9, J4.3 (SCK)
/PB2_MOSI: J3.7, J4.4 (MOSI)
/PB3_MISO: J3.8, J4.1 (MISO)
/PB4_OC2A: J3.6
/PB5_OC1A: J3.5
/PB6_OC1B: J3.4
/PB7_OC0A: J3.3
/PD0_SCL_INT0: J1.3, J2.3, J3.16
/PD1_SDA_INT1: J1.4, J2.4, J3.15
/PD2_RXD1_INT2: J3.21
/PD3_TXD1_INT3: J3.22
/PE0_RXD0: J3.19, U2.4 (TX)
/PE1_TXD0: J3.20, U2.8 (RX)
/PE3_OC3A: J3.23
/PE4_OC3B_INT4: J3.24
/PE5_OC3C_INT5: J3.25
/PF2_ADC2: J3.18
/PF3_ADC3: J3.17
/PF4_ADC4_TCK: J3.14, J5.1 (TCK)
/PF5_ADC5_TMS: J3.13, J5.5 (TMS)
/PF6_ADC6_TDO: J3.12, J5.3 (TDO)
/PF7_ADC7_TDI: J3.11, J5.9 (TDI)
/RESET: J3.26, J4.5 (~RST), J5.6 (~SRST)
GND: C1.2, C2.2, C3.2, C4.2, J1.2, J2.2, J3.27, J4.6 (GND), J5.2 (GND), J5.10 (GND), J6.5 (GND), J6.6 (Shield), U1.1 (GND), U2.9 (GND)
unnamed: C1.1, R2.2, U2.6 (UDET), U2.10 (D-)
unnamed: C2.1, R1.1, U2.1 (D+)
unnamed: C4.1, U2.3 (V33O)
unnamed: D1.1 (K), U2.5 (LED)
unnamed: D1.2 (A), R3.2
unnamed: J6.2 (D-), R2.1
unnamed: J6.3 (D+), R1.2

Board: 2 copper layers, 55.9 x 35.6 mm, 16 parts (0 on the bottom side), 22 nets.

## Commit log

2020-03-23 lib: Added footprints/symbols for boards
2020-03-23 Added atmega328p board
2020-03-23 Added atmega1284p board
2020-03-23 lib: Added Microduino CoreRF header
2020-03-23 Added adapter board for Microduino CoreRF
2020-03-24 atmega1284p: Use 12MHz crystal and 3.3V
    This way the board is safe to used with the CC1101
2020-04-21 atmega328p: Improved silkscreen labels
2020-05-08 Some changes to the PCBs, I guess. No idea
2020-05-12 Added board for ATmega1284P breakout
2020-05-12 corerf: Fixed silkscreen-label & drill size
2020-05-13 Added xmas tree PCB
2020-07-23 Fixed net of 3.3V pins
2020-08-23 Fix m1284p xtimer settings
2022-05-30 riot/m1284p: update to current master
2022-09-09 riot/m1284p: update to current master & SD card conf
2023-02-27 treewide: Update to KiCAD 7
2023-02-27 4dof-arm: Add board for controlling 4dof arms with a bluepill
2023-02-28 4dof-arm: Fix nRF24L01+ CE and IRQ signal
2023-02-28 riot: Add 4dof-arm as RIOT board
2023-03-11 riot/4dof-arm: USB CDC ACM now works :)
2023-03-12 bluepill-stm32f103cb-4dof-arm: renamed from 4dof-arm
2023-03-12 riot: Add board files for nucleo-f446re-remote
2023-06-06 testing-shield: Arduino shield for loopback testing
2023-06-07 lib: update to new version and add CH4340N
2023-06-07 atmega1284p: Use CH340N as TTL adapter
2023-06-09 boards: add Arduino adapter for Olimex MSP430 header boards
2023-06-29 riot/m1284p: update to TTL adapter change
2023-06-29 testing-shield: Fix R-2R DAC resistor values
2023-06-29 testing-shield: do not connect to 5V pin of ISP
    Some boards (e.g. the Seeeduino) do not have 5V but VCC there.
2023-06-29 testing-shield: connect SCK lines to GPIO extender
    This allows reading the SPI clock polarity when the SPI clock is
    idle.
